Commit message: moah testing stuff

File: gym_flexassembly/data/frame_ghost.urdf (robot description, URDF)
Before this commit: robot urdf_robot, 1 links, 0 joints
Links:
- link baseLink: geometry collision sphere radius=0.01; visual sphere radius=0.01
